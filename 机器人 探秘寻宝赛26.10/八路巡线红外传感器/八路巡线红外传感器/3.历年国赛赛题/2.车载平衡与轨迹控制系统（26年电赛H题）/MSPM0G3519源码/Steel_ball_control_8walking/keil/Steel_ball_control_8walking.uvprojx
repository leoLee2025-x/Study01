# Keil uVision project Steel_ball_control_8walking.uvprojx, settings and files
target empty_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Steel_ball_control_8walking +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\..\Steel_ball_control_8walking;..\BSP\eMPL;..\BSP\Motor;..\BSP\Eight_Tracking;..\BSP\Key;..\BSP\Task;..\BSP\LED;..\BSP\Timer;..\BSP\Buzzer;..\BSP\MPU6050;..\BSP\Questions;..\BSP\Task;..\BSP;..\APP;..\BSP\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  group Source
    ../: main.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
  group Driverlib
    ../ti/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c dl_factoryregion.c dl_interrupt.c dl_sysctl_mspm0c110x.c dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0gx51x.c dl_sysctl_mspm0l11xx_l13xx.c dl_sysctl_mspm0l122x_l222x.c
  group BSP
    ../BSP/: delay.c usart.c Filter.c
    ../BSP/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BSP/Eight_Tracking/: app_irtracking.c
    ../BSP/Motor/: app_motor.c app_motor_usart.c bsp_motor_usart.c
    ../BSP/Key/: key.c
    ../BSP/LED/: led.c
    ../BSP/Timer/: timer.c
    ../BSP/MPU6050/: app_mpu6050.c bsp_mpu6050.c
    ../BSP/Task/: task.c
    ../BSP/Questions/: questions.c
    ../BSP/OLED/: oled.c
  group APP
    ../APP/: app_kalman.c app_pid.c app_servo.c app_k230.c
